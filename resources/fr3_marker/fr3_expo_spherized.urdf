Commit message: added marker fixed ruby

File: resources/fr3_marker/fr3_expo_spherized.urdf (robot description, URDF)
Before this commit: robot fr3, 14 links, 13 joints
Links:
- link fr3_tip: geometry collision sphere radius=0.0150744257597252727; collision sphere radius=0.0150807309299707413
